Commit message: State_Machine with kowledge_base

File: assignment2/urdf/my_robot.urdf (robot description, URDF)
Before this commit: robot my_robot, 11 links, 10 joints
Joints:
- joint joint_laser: origin xyz=0.15 0 0.05 rpy=0 0 0 -> xyz=0.15 0 0.20 rpy=0 0 0
